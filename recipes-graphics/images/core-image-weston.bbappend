CORE_IMAGE_EXTRA_INSTALL = " \
    fcitx5 \
    fcitx5-configtool \
    fcitx5-chinese-addons \
    "