INIT_MANAGER = " systemd"
DISTRO_FEATURES:append = " wayland x11 kde"